# IAR project hidi2c-mouse.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 512
  General.GHeapSize2: 512
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: hidi2c; hidi2c/hid; hidi2c/i2c; hidi2c/i2c/usci; 
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: hidi2c_settings.h main.c
  group hidi2c
    hidi2c/: hidi2c_errno.h types.h
    ./: mouse_descriptors.h
  group hidi2c/hid
    hidi2c/hid/: hid_engine.c hid_engine.h hid_reportparser.c hid_reportparser.h
  group hidi2c/i2c/usci
    hidi2c/i2c/usci/: i2c_engine_usci.c i2c_engine_usci.h i2c_engine_usci_init.c i2c_engine_usci_init.h
