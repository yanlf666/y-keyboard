<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\keyboard\hidi2c-keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mouse\hidi2c-mouse.ewp</path>
  </project>
  <batchBuild/>
</workspace>


